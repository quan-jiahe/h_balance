# Keil uVision project F103_K230_Center_Balance.uvprojx, settings and files
target F103_K230_Center_Balance (6240000::V6.24::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: F103_K230_Center_Balance +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F103xB,F407_CENTER_BALANCE
  c misc: -std=c11 -Wall -Wextra
  c include: ..\..\stm32f407_uart_test\Core\Inc;..\..\stm32f407_uart_test\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\stm32f103c8.sct
  link misc: --strict
  group Application
    ../../stm32f407_uart_test/Core/Src/: main.c board.c link_test.c startup_level.c pulse_cycle.c center_balance.c vofa_uart.c vofa_tuning.c center_oled.c
  group Startup
    ../Startup/: startup_stm32f103xb.s
  group Headers
    ../../stm32f407_uart_test/Core/Inc/: vofa_uart.h vofa_tuning.h balance_tuning.h board.h link_test.h startup_level.h
