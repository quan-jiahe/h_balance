# Keil uVision project F407_K230_UART.uvprojx, settings and files
target F407_K230_UART (6240000::V6.24::ARMCLANG)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: F407_K230_UART +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx
  c misc: -std=c11 -Wall -Wextra
  c include: ..\Core\Inc;..\Drivers\CMSIS\Core\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include
  asm define: __MICROLIB
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\stm32f407ve.sct
  link misc: --strict
  group Application
    ../Core/Src/: main.c board.c link_test.c
  group Startup
    ../Startup/: startup_stm32f407xx.s
  group Headers
    ../Core/Inc/: board.h link_test.h
